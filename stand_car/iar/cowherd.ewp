# IAR project cowherd.ewp, settings and files
configuration KEA_128_RAM (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 Freescale KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; TWR_K60N512; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\device\H; ..\user\H; ..\system; ..\lib\H; ..\system\coreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cowherd.hex
  ILINK.IlinkOutputFile: cowherd.out
  ILINK.IlinkIcfFile: ..\system\link\KEAZ128_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration KEA_128_FLASH (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512; _DLIB_FILE_DESCRIPTOR; DA_OLED
  ILINK.IlinkIcfFile: ..\system\link\KEA128.icf
  group Device/C
    ../device/C/: adc.c ftm.c iicAnalog.c key.c L3G4200.c oled.c outputdata.c outputdata_shanwai.c pit.c spi.c uart.c
  group Device/H
    ../device/H/: adc.h ftm.h iicAnalog.h key.h L3G4200.h oled.h outputdata.h outputdata_shanwai.h pit.h spi.h uart.h
  group Lib/C
    ../lib/C/: KEA128_adc.c KEA128_flash.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_port.c KEA128_systick.c KEA128_uart.c
  group Lib/H
    ../lib/H/: common.h KEA128_adc.h KEA128_flash.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_port.h KEA128_port_cfg.h KEA128_systick.h KEA128_uart.h
  group System/coreSupport
    ../system/coreSupport/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group System/Link
    ../system/link/: KEA128.icf KEAZ128_RAM.icf kea链接文件说明.txt
  group System/Startup_Code
    ../system/: startup_SKEAZ1284.s
  group System/system_need
    ../system/: SKEAZ1284.h system_SKEAZ1284.c system_SKEAZ1284.h
  group User
    ../user/: 备注.txt
  group User/C
    ../user/C/: balanceControl.c common.c Direction_Control.c Fuzzy.c inductor_1.c main.c Motor_Control.c Speed_Control.c
  group User/H
    ../user/H/: allHead.h balanceControl.h Direction_Control.h Fuzzy.h inductor_1.h Motor_Control.h Speed_Control.h Variable.h
